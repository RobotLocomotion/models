Commit message: Models with no inertia properties are dangerous. We add non-zero inertia properties to this model

File: dishes/table_top.urdf (robot description, URDF)
Before this commit: robot table_top, 1 links, 0 joints
Links:
- link table_top_link: mass None -> 30
